# IAR project Stm32F4x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx
  ICCARM.CCIncludePath2: ..\..\..\Components\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Components\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Components\Utilities; ..\..\..\Components; ..\..\..\Components\BSP; ..\..\Components\BSP\Stm32F4x_BSP\inc; ..\..\Components\MDL\cshell; ..\..\Components\MDL\clog; ..\..\Components\MDL\header; ..\..\Components\MDL\ModbusRTU; ..\Source\application; ..\Source\application\gui_task; ..\Source\FML\System; $PROJ_DIR$; ..\Source\FML; ..\..\Components\MDL\osal\ports; ..\..\Components\MDL\rttviewer; ..\..\Components\MDL\osal\src; ..\..\Components\BSP; ..\Source\application\user_Task; ..\..\..\Components\Utilities; ..\Source\FML\GUI; ..\Source\FML\GUI\GUI_Driver\inc; ..\Source\application\finger_task
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Stm32F4x.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Application
    ../Source/application/: main.c self_def.h stm32f4xx_it.c
  group Application/finger_task
    ../Source/application/finger_task/: finger_task.c
  group Application/gui_task
    ../Source/application/gui_task/: gui_task.c
  group Application/user_task
    ../Source/application/user_Task/: user_task.c
  group bsp
    ../../Components/BSP/: bsp_init.c bsp_lcd.c
  group bsp/stm32f4x_bsp/src
    ../../Components/BSP/Stm32F4x_BSP/src/: stm32f4xx_bsp_exti.c stm32f4xx_bsp_systick.c stm32f4xx_bsp_usart.c
  group cmsis
    ../../../Components/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
    ../../../Components/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Driver
    ../../../Components/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group fml/GUI/ports
    ../Source/FML/GUI/: gui_conf.c gui_fun.c
  group fml/GUI/src
    ../Source/FML/GUI/: gui_cmd_queue.c gui_process.c
  group fml/GUI/src/GUI_Driver
    ../Source/FML/GUI/GUI_Driver/src/: gui_base.c gui_batch.c gui_button.c gui_controlproperty.c gui_curve.c gui_flash.c gui_general.c gui_gif.c gui_graphics.c gui_historygraph.c gui_icon.c gui_image.c gui_label.c gui_menu.c gui_meter.c gui_music.c gui_progress.c gui_QR.c gui_record.c gui_rtc.c gui_sdcard.c gui_selector.c gui_slider.c gui_text.c gui_timer.c
  group fml/System
    ../Source/FML/System/: system_info.c system_init.c system_param.c
  group mdl
    ../../Components/MDL/: cqueue.c cstring.c
  group mdl/clog
    ../../Components/MDL/clog/: clog.c flash_log.c rtt_log.c serial_log.c
  group mdl/cshell
    ../../Components/MDL/cshell/: cshell.c cshell_port.c cshell_user.c
  group mdl/osal/ports
    ../../Components/MDL/osal/ports/: osal_cpu.c
  group mdl/osal/src
    ../../Components/MDL/osal/src/: osal.c osal_cfg.c osal_clock.c osal_core.c osal_msg.c osal_task.c osal_timeout.c osal_timer.c
  group mdl/RTTViewer
    ../../Components/MDL/rttviewer/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group uti
    ../../../Components/Utilities/: crc.c
